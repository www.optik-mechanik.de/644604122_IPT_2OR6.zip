# Autodesk Inventor part: 2OR6-55T_uzsakovui
## iProperties
Created: 2007-06
Part Number: 2OR6-55T_uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
