# Autodesk Inventor part: 2OR6-470internetui
## iProperties
Created: 2010-11
Part Number: 2OR6-470internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
